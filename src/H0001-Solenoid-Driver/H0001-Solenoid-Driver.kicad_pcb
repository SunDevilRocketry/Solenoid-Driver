# Repository SunDevilRocketry/Solenoid-Driver

File README.md:

<h1>Solenoid Driver</h1>

<p>Current PCB Revision: 1.0</p>
<p>PCB Part Number: H0001</p>

<p>The solenoid driver uses solid state relays to allow an Arduino Mega 
to control AC powered solenoids with a 5V control signal. The board is 
used by the SDR Hybrid Propulsion team to control their Pancake engine's 
pressurization and main oxidizer valves. </p>

<p><b>Working Directory Structure:</b></p>

<p>
   doc: documentation
   
   src: source design files, e.g. schematic and PCB layout files

   lib: libraries for schematic symbols and footprints

   production: files needed for pcb fabrication, e.g. gerbers, profile, drill file

   sim: simulation models/files 

   cad: 3d models
  
   img: images of circuit/footprints for github display 
</p>

<h2>3D Model: </h2>

<h2>Schematic:</h2>

<h3>Solenoid Driver</h3>

<h3>Signals and Power</h3>

## KiCad design src/H0001-Solenoid-Driver/H0001-Solenoid-Driver.kicad_pcb

Parts:
C1, C2: 0.1uF; CAP_1206
F1: 0678L9100-02; FUSC9830X318N
H1, H2, H3: Mounting-Hole; MountingHole_4.3mm_M4_DIN965
K1, K2: AQH0223AX; RELAY_AQH0223AX
LOGO1: Logo
P1: 647676-2; TE_647676-2
P2: 647676-3
P3, P4: 647676-3; 353130360
R1, R3: 180; RES_0603
R2, R4: 100; RES_0603
RV1, RV2: 275V; PV275K4032R2

Connections:
AC_HOT: F1.2, P3.2, P4.2
AC_NEU: K1.6, K2.6, P1.1, R2.1, R4.1, RV1.2, RV2.2
Earth: P2.1, R1.1, R3.1
unnamed: C1.1, K1.8, P3.1, RV1.1
unnamed: C1.2, R2.2
unnamed: C2.1, K2.8, P4.1, RV2.1
unnamed: C2.2, R4.2
unnamed: F1.1, P1.2
unnamed: K1.4, R1.2
unnamed: K2.4, R3.2
OX: K2.2, P2.2
PRESS: K1.2, P2.3

Notes on the sheet:
Oxidizer Solenoid
Solenoid 2
Connectors
Solenoid 1
Misc.
Pressurization Solenoid

Board: 2 copper layers, 75.2 x 35.4 mm, 19 parts (0 on the bottom side), 12 nets.

## Commit log

2022-12-24 copied over files from old repository
